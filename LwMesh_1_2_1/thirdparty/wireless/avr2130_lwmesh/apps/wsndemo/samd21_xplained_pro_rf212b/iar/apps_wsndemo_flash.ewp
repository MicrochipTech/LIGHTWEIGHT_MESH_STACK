# IAR project apps_wsndemo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; PHY_AT86RF212B; RTC_COUNT_ASYNC=true; BOARD=SAMD21_XPLAINED_PRO; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=false; SAL_TYPE=AT86RF2xx; __SAMD21J18A__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\sam0\drivers\rtc\rtc_sam_d_r_h; ..\..\..\..\..\services\trx_access; ..\..\..\..\..\services\common_hw_timer; ..\..\..\..\..\..\..\sam0\utils\header_files; ..\..\..\..\..\..\..\sam0\drivers\sercom\spi; ..\..\..\..\..\..\..\sam0\drivers\tc; ..\..\..\..\..\..\..\common2\services\delay; ..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\sam0\drivers\sercom; ..\..\..\..\..\..\..\sam0\drivers\system\clock\clock_samd21_r21_da_ha1; ..\..\..\..\..\..\..\sam0\drivers\system\interrupt; ..\..\..\..\..\..\..\sam0\utils\cmsis\samd21\include; ..\..\..\..\..\..\..\sam0\drivers\system\reset\reset_sam_d_r_h; ..\..; ..\..\..\..\..\services\sleep_mgr; ..\..\..\..\..\..\..\sam0\drivers\system\pinmux; ..\..\..\..\..\..\..\sam0\drivers\tc\tc_sam_d_r_h; ..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\sam0\drivers\rtc; ..\..\..\..\..\..\..\sam0\drivers\system; ..\..\..\..\..\..\..\sam0\drivers\system\clock; ..\..\..\..\..\..\..\sam0\drivers\sercom\usart; ..\..\..\..\..\..\..\sam0\drivers\port; ..\..\..\..\..\..\..\sam0\drivers\system\reset; ..\..\..\..\..\..\..\sam0\drivers\system\power\power_sam_d_r_h; ..\..\..\..\..\services\sal\inc; ..\..\..\..\..\..\..\sam0\drivers\system\interrupt\system_interrupt_samd21; ..\..\..\..\..\..\..\sam0\drivers\extint\extint_sam_d_r_h; ..\..\..\..\..\..\..\sam0\utils\cmsis\samd21\source; ..\..\..\..\source\phy\at86rf212b\inc; ..; ..\..\..\..\..\..\..\sam0\utils; ..\..\..\..\source\sys\inc; ..\..\..\..\..\..\..\sam0\boards; ..\..\..\..\..\services\common_hw_timer\sam0; ..\..\..\..\..\..\..\sam0\boards\samd21_xplained_pro; ..\..\..\..\..\..\..\sam0\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\sam0\drivers\system\power; ..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\sam0\utils\preprocessor; ..\..\..\..\..\..\..\common2\services\delay\sam0; ..\..\..\..\..\..\..\sam0\drivers\extint; ..\..\..\..\source\nwk\inc; ..\..\..\..\..\addons\sio2host\uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_wsndemo_flash.bin
  ILINK.IlinkOutputFile: apps_wsndemo_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\sam0\utils\linker_scripts\samd21\iar\samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal.h sal_types.h sal_generic.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/sam0
    ../../../../../services/sleep_mgr/sam0/: sleep_mgr.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sysTimer.c sys.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sysTimer.h sys.h sysConfig.h sysEncrypt.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkGroup.c nwkTx.c nwkSecurity.c nwkRx.c nwkRouteDiscovery.c nwkFrame.c nwkRoute.c nwkDataReq.c nwk.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkTx.h nwkSecurity.h nwkFrame.h nwk.h nwkRouteDiscovery.h nwkDataReq.h nwkRx.h nwkGroup.h nwkRoute.h nwkCommand.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/src
    ../../../../source/phy/at86rf212b/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/inc
    ../../../../source/phy/at86rf212b/inc/: phy.h at86rf212b.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: main.c wsndemo.c commands.c config.h commands.h wsndemo.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/samd21_xplained_pro_rf212b
    ../: conf_hw_timer.h conf_spi.h conf_sio2host.h conf_clocks.h conf_sleepmgr.h conf_board.h conf_extint.h conf_trx_access.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/samd21_xplained_pro_rf212b/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/rtc
    ../../../../../../../sam0/drivers/rtc/: rtc_tamper.h rtc_count.h rtc_count_interrupt.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h/: rtc_count.c rtc_count_interrupt.c
  group sam0/drivers/tc
    ../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../../../../sam0/drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../sam0/utils/cmsis/samd21/include/: samd21e16l.h samd21g17l.h samd21e15b.h samd21e17d.h samd21e15a.h samd21j16b.h samd21e18a.h samd21g17a.h samd21j17a.h samd21g18a.h samd21e15l.h samd21g16l.h samd21j18a.h samd21j16a.h samd21g15l.h samd21e16b.h samd21g17d.h samd21e17du.h samd21g18au.h samd21g15a.h samd21j15b.h samd21.h samd21e15bu.h samd21g16a.h samd21e16bu.h samd21e16a.h samd21j15a.h samd21e17l.h samd21g16b.h samd21e17a.h samd21g17au.h samd21g15b.h samd21j17d.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21g17au.h samd21j16a.h samd21g17a.h samd21g16b.h samd21e17du.h samd21g17d.h samd21g15b.h samd21e17l.h samd21g16l.h samd21e15l.h samd21e16b.h samd21e15bu.h samd21e15a.h samd21j16b.h samd21e17d.h samd21g16a.h samd21e16bu.h samd21e16l.h samd21g17l.h samd21j18a.h samd21j15b.h samd21e18a.h samd21g15a.h samd21e15b.h samd21e16a.h samd21g18a.h samd21e17a.h samd21j15a.h samd21j17d.h samd21g15l.h samd21g18au.h samd21j17a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../sam0/utils/cmsis/samd21/include/component/: sercom.h mtb.h sysctrl.h usb.h dsu.h i2s.h adc.h wdt.h pm.h dmac.h dac.h hmatrixb.h pm_variant_d.h pac.h eic.h evsys.h nvmctrl_variant_d.h nvmctrl.h tcc_variant_d.h port.h tcc.h ac.h tc.h rtc.h tcc_lighting.h evsys_variant_d.h gclk.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../sam0/utils/cmsis/samd21/include/instance/: ac1.h sercom1.h i2s.h port.h mtb.h pac0.h port_variant_d.h tcc0.h dmac.h pm.h ac.h tc3.h gclk.h dsu.h evsys.h tcc1.h sercom2.h rtc.h sercom0.h sysctrl.h evsys_variant_d.h tc6.h tc4.h usb.h sercom5.h sercom3.h tc5.h pac1.h sercom4.h pac2.h wdt.h nvmctrl.h tcc2.h sbmatrix.h eic.h tc7.h adc.h tcc3.h dac.h nvmctrl_variant_d.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: preprocessor.h mrecursion.h mrepeat.h stringz.h tpaste.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
