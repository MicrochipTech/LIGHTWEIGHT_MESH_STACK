# IAR project apps_wsndemo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_XPLAINED_PRO; SAL_TYPE=AT86RF2xx; ARM_MATH_CM4=true; __SAM4SD32C__; PHY_AT86RF233
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\services\trx_access; ..\..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\services\common_hw_timer; ..\..\..\..\..\services\common_hw_timer\sam; ..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\..\sam\drivers\rtt; ..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\common\services\spi; ..\..\..\..\..\..\..\sam\utils\cmsis\sam4s\include; ..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\services\sleep_mgr; ..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\source\nwk\inc; ..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\sam\drivers\pio; ..; ..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\services\sal\inc; ..\..\..\..\..\..\..\sam\boards\sam4s_xplained_pro; ..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\source\sys\inc; ..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..; ..\..\..\..\..\..\..\sam\utils\cmsis\sam4s\source\templates; ..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\common\services\spi\sam_spi; ..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\source\phy\at86rf233\inc; ..\..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\addons\sio2host\uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_wsndemo_flash.bin
  ILINK.IlinkOutputFile: apps_wsndemo_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\sam\utils\linker_scripts\sam4s\sam4sd32\iar\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam
    ../../../../../services/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam/lib
    ../../../../../services/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal.h sal_types.h sal_generic.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/sam
    ../../../../../services/sleep_mgr/sam/: sleep_mgr.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sysTimer.c sys.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sys.h sysTimer.h sysConfig.h sysEncrypt.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkGroup.c nwkTx.c nwkSecurity.c nwkRx.c nwkRouteDiscovery.c nwkFrame.c nwkRoute.c nwkDataReq.c nwk.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkTx.h nwkSecurity.h nwkFrame.h nwk.h nwkDataReq.h nwkRx.h nwkRouteDiscovery.h nwkGroup.h nwkRoute.h nwkCommand.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/src
    ../../../../source/phy/at86rf233/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/inc
    ../../../../source/phy/at86rf233/inc/: phy.h at86rf233.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: main.c commands.c wsndemo.c config.h wsndemo.h commands.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/sam4sd32c_reb233_xpro
    ../: conf_spi_master.h conf_sio2host.h conf_hw_timer.h conf_sleepmgr.h conf_board.h conf_clock.h conf_trx_access.h conf_uart_serial.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/sam4sd32c_reb233_xpro/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam/drivers/rtt
    ../../../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/wdt
    ../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/supc
    ../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/tc
    ../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../sam/utils/cmsis/sam4s/include/: sam4sd32b.h sam4sa16c.h sam4s.h system_sam4s.h sam4s4b.h sam4s16b.h sam4sa16b.h sam4sd16c.h sam4s2a.h sam4s2b.h sam4s4a.h sam4s4c.h sam4s16c.h sam4sd16b.h sam4s8c.h sam4s2c.h sam4s8b.h sam4sd32c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_wdt.h instance_rtc.h instance_supc.h instance_pioc.h instance_usart0.h instance_adc.h instance_matrix.h instance_uart0.h instance_pioa.h instance_tc0.h instance_dacc.h instance_efc1.h instance_smc.h instance_gpbr.h instance_cmcc.h instance_usart1.h instance_piob.h instance_acc.h instance_udp.h instance_tc1.h instance_spi.h instance_efc0.h instance_pwm.h instance_ssc.h instance_hsmci.h instance_twi1.h instance_crccu.h instance_pmc.h instance_rstc.h instance_rtt.h instance_uart1.h instance_chipid.h instance_twi0.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_matrix.h component_ssc.h component_cmcc.h component_adc.h component_usart.h component_efc.h component_uart.h component_pmc.h component_pdc.h component_dacc.h component_twi.h component_tc.h component_chipid.h component_pwm.h component_acc.h component_rtc.h component_gpbr.h component_supc.h component_udp.h component_smc.h component_rtt.h component_pio.h component_wdt.h component_rstc.h component_hsmci.h component_spi.h component_crccu.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s16b.h pio_sam4sa16c.h pio_sam4s4c.h pio_sam4s16c.h pio_sam4sd32b.h pio_sam4s2c.h pio_sam4sa16b.h pio_sam4s4b.h pio_sam4sd16b.h pio_sam4s4a.h pio_sam4s8c.h pio_sam4s2a.h pio_sam4sd32c.h pio_sam4s2b.h pio_sam4sd16c.h pio_sam4s8b.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4s_xplained_pro
    ../../../../../../../sam/boards/sam4s_xplained_pro/: init.c sam4s_xplained_pro.h led.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam4s
    ../../../../../../../common/services/clock/sam4s/: sysclk.c genclk.h osc.h sysclk.h pll.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
