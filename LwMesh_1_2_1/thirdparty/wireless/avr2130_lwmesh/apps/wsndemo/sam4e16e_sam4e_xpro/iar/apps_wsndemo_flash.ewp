# IAR project apps_wsndemo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_XPLAINED_PRO; __SAM4E16E__; SAL_TYPE=AT86RF2xx; ARM_MATH_CM4=true; PHY_AT86RF233
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\services\trx_access; ..\..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\services\common_hw_timer; ..\..\..\..\..\services\common_hw_timer\sam; ..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\source\phy\at86rf233\inc; ..\..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\..\sam\drivers\rtt; ..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\common\services\spi; ..\..\..\..\..\..\..\sam\boards; ..; ..\..\..\..\..\..\..\sam\drivers\pmc; ..\..\..\..\..\services\sleep_mgr; ..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\source\nwk\inc; ..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\..\sam\utils\cmsis\sam4e\include; ..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\services\sal\inc; ..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\source\sys\inc; ..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..; ..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\common\services\spi\sam_spi; ..\..\..\..\..\..\..\sam\boards\sam4e_xplained_pro; ..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\sam\utils\cmsis\sam4e\source\templates; ..\..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\addons\sio2host\uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_wsndemo_flash.bin
  ILINK.IlinkOutputFile: apps_wsndemo_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\sam\utils\linker_scripts\sam4e\sam4e16\iar\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam
    ../../../../../services/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam/lib
    ../../../../../services/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal.h sal_types.h sal_generic.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/sam
    ../../../../../services/sleep_mgr/sam/: sleep_mgr.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sysTimer.c sys.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sysTimer.h sys.h sysConfig.h sysEncrypt.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkGroup.c nwkTx.c nwkSecurity.c nwkRx.c nwkRouteDiscovery.c nwkFrame.c nwkRoute.c nwkDataReq.c nwk.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkDataReq.h nwkTx.h nwkSecurity.h nwkRouteDiscovery.h nwkFrame.h nwk.h nwkRoute.h nwkRx.h nwkGroup.h nwkCommand.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/src
    ../../../../source/phy/at86rf233/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf233/inc
    ../../../../source/phy/at86rf233/inc/: phy.h at86rf233.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: main.c commands.c wsndemo.c commands.h config.h wsndemo.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/sam4e16e_sam4e_xpro
    ../: conf_spi_master.h conf_hw_timer.h conf_sio2host.h conf_sleepmgr.h conf_board.h conf_clock.h conf_trx_access.h conf_uart_serial.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/sam4e16e_sam4e_xpro/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam/drivers/rtt
    ../../../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/supc
    ../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/tc
    ../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/boards/sam4e_xplained_pro
    ../../../../../../../sam/boards/sam4e_xplained_pro/: init.c led.h sam4e_xplained_pro.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../../sam/utils/cmsis/sam4e/include/: sam4e16e.h sam4e16c.h sam4e.h sam4e8cb.h sam4e16cb.h sam4e8e.h sam4e8c.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../../sam/utils/cmsis/sam4e/include/component/: rstc.h twi.h pwm.h aes.h pdc.h dacc.h pio.h rtt.h wdt.h gpbr.h matrix.h spi.h can.h udp.h afec.h efc.h usart.h smc.h rtc.h rswdt.h acc.h hsmci.h dmac.h cmcc.h pmc.h gmac.h tc.h chipid.h uart.h supc.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../../sam/utils/cmsis/sam4e/include/instance/: usart1.h pmc.h cmcc.h supc.h usart0.h uart1.h pioa.h efc.h pioc.h gpbr.h tc2.h rswdt.h tc0.h afec1.h pioe.h piob.h smc.h afec0.h aes.h rstc.h uart0.h tc1.h twi0.h pwm.h dmac.h rtc.h twi1.h piod.h matrix.h can1.h hsmci.h spi.h acc.h can0.h chipid.h rtt.h dacc.h wdt.h udp.h gmac.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e16e.h sam4e16cb.h sam4e8e.h sam4e16c.h sam4e8c.h sam4e8cb.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../../sam/utils/fpu/: fpu.h
  group common/services/clock
    ../../../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam4e
    ../../../../../../../common/services/clock/sam4e/: sysclk.c osc.h genclk.h pll.h sysclk.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
