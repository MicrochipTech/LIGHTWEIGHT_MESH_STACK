# IAR project apps_wsndemo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4LC4C__; PHY_AT86RF212B; SAL_TYPE=AT86RF2xx; ARM_MATH_CM4=true; BOARD=SAM4L_XPLAINED_PRO
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\services\trx_access; ..\..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\services\common_hw_timer; ..\..\..\..\..\services\common_hw_timer\sam; ..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\sam\drivers\bpm; ..\..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\common\services\spi; ..\..\..\..\..\..\..\sam\boards\sam4l_xplained_pro; ..\..\..\..\..\..\..\sam\utils\cmsis\sam4l\include; ..\..\..\..\..\..\..\sam\boards; ..\..; ..\..\..\..\..\services\sleep_mgr; ..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\source\nwk\inc; ..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\sam\drivers\ast\example2; ..\..\..\..\..\..\..\sam\drivers\ast\example1; ..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\services\sal\inc; ..\..\..\..\..\..\..\sam\drivers\gpio; ..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\source\phy\at86rf212b\inc; ..\..\..\..\source\sys\inc; ..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\..\sam\drivers\ast; ..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\sam\utils\cmsis\sam4l\source\templates; ..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\common\services\spi\sam_spi; ..\..\..\..\..\..\..\sam\drivers\flashcalw; ..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\addons\sio2host\uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_wsndemo_flash.bin
  ILINK.IlinkOutputFile: apps_wsndemo_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\sam\utils\linker_scripts\sam4l\sam4l4\iar\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam
    ../../../../../services/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam/lib
    ../../../../../services/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal.h sal_types.h sal_generic.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/sam4l
    ../../../../../services/sleep_mgr/sam4l/: sleep_mgr.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sysTimer.c sys.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sysTimer.h sys.h sysConfig.h sysEncrypt.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkGroup.c nwkTx.c nwkSecurity.c nwkRx.c nwkRouteDiscovery.c nwkFrame.c nwkRoute.c nwkDataReq.c nwk.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkSecurity.h nwk.h nwkRouteDiscovery.h nwkFrame.h nwkTx.h nwkDataReq.h nwkRx.h nwkGroup.h nwkRoute.h nwkCommand.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/src
    ../../../../source/phy/at86rf212b/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/inc
    ../../../../source/phy/at86rf212b/inc/: phy.h at86rf212b.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: main.c commands.c wsndemo.c commands.h config.h wsndemo.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/sam4lc4c_rf212b_zigbit_ext
    ../: conf_ast.h conf_spi_master.h conf_hw_timer.h conf_clock.h conf_sio2host.h conf_trx_access.h conf_sleepmgr.h conf_board.h conf_uart_serial.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/sam4lc4c_rf212b_zigbit_ext/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../sam/boards/sam4l_xplained_pro/: init.c sam4l_xplained_pro.h led.h
  group sam/drivers/ast
    ../../../../../../../sam/drivers/ast/: ast.c ast.h
  group sam/drivers/ast/example2
    ../../../../../../../sam/drivers/ast/example2/: ast_example2.h
  group sam/drivers/ast/example1
    ../../../../../../../sam/drivers/ast/example1/: ast_example1.h
  group sam/drivers/gpio
    ../../../../../../../sam/drivers/gpio/: gpio.c gpio.h
  group sam/drivers/wdt
    ../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/bpm
    ../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/tc
    ../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/flashcalw
    ../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../sam/utils/cmsis/sam4l/include/: sam4lc8b.h sam4ls2a.h sam4ls2c.h sam4lc4a.h sam4lc2c.h sam4ls8a.h sam4lc2a.h sam4ls4c.h sam4ls8c.h sam4ls2b.h sam4lc2b.h sam4ls4a.h sam4lc4c.h sam4ls8b.h sam4ls4b.h sam4l.h sam4lc8a.h sam4lc4b.h sam4lc8c.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_tc1.h instance_usart2.h instance_picouart.h instance_dacc.h instance_usart0.h instance_pdca.h instance_trng.h instance_bpm.h instance_aesa.h instance_iisc.h instance_acifc.h instance_twim1.h instance_tc0.h instance_spi.h instance_parc.h instance_twim3.h instance_lcdca.h instance_crccu.h instance_abdacb.h instance_twis0.h instance_pm.h instance_ast.h instance_chipid.h instance_gpio.h instance_eic.h instance_twim2.h instance_twis1.h instance_usbc.h instance_adcife.h instance_pevc.h instance_scif.h instance_hcache.h instance_bscif.h instance_usart3.h instance_catb.h instance_twim0.h instance_usart1.h instance_hflashc.h instance_hmatrix.h instance_wdt.h instance_freqm.h instance_smap.h instance_gloc.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_iisc.h component_chipid.h component_aesa.h component_dacc.h component_pdca.h component_catb.h component_abdacb.h component_gpio.h component_bpm.h component_eic.h component_pevc.h component_spi.h component_smap.h component_wdt.h component_twim.h component_picouart.h component_trng.h component_hcache.h component_scif.h component_crccu.h component_acifc.h component_hmatrixb.h component_tc.h component_adcife.h component_gloc.h component_lcdca.h component_usart.h component_flashcalw.h component_freqm.h component_parc.h component_twis.h component_ast.h component_bscif.h component_pm.h component_usbc.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc8b.h pio_sam4lc4b.h pio_sam4lc2c.h pio_sam4lc2a.h pio_sam4lc8c.h pio_sam4ls8b.h pio_sam4lc4a.h pio_sam4lc4c.h pio_sam4ls8c.h pio_sam4ls4b.h pio_sam4lc8a.h pio_sam4ls2c.h pio_sam4ls2a.h pio_sam4ls4c.h pio_sam4ls2b.h pio_sam4lc2b.h pio_sam4ls8a.h pio_sam4ls4a.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h tpaste.h stringz.h preprocessor.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h dfll.h
  group common/services/clock/sam4l
    ../../../../../../../common/services/clock/sam4l/: osc.c sysclk.c dfll.c pll.c osc.h dfll.h pll.h genclk.h sysclk.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
