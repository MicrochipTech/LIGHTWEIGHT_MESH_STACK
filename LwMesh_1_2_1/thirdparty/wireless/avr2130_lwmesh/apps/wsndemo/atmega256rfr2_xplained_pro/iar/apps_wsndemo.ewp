# IAR project apps_wsndemo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: SAL_TYPE=ATMEGARF_SAL; BOARD=ATMEGA256RFR2_XPLAINED_PRO; PHY_ATMEGARFR2
  ICCAVR.newCCIncludePaths: ..\..\..\..\..\..\..\mega\boards\atmega256rfr2_xplained_pro; ..\..\..\..\..\..\..\common\services\serial\megarf_usart; ..\..\..\..\..\..\..\mega\utils; ..\..\..\..\..\services\common_hw_timer; ..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\mega\drivers\cpu; ..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\mega\drivers\usart; ..\..; ..\..\..\..\..\services\sleep_mgr; ..\..\..\..\..\..\..\mega\boards; ..\..\..\..\..\..\..\mega\drivers\macsc; ..\..\..\..\source\nwk\inc; ..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\source\phy\atmegarfr2\inc; ..; ..\..\..\..\..\services\sal\inc; ..\..\..\..\..\services\common_hw_timer\mega; ..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\services\mega\drivers\tc; ..\..\..\..\..\..\..\mega\drivers\sleep; ..\..\..\..\source\sys\inc; ..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\mega\utils\preprocessor; ..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\addons\sio2host\uart; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; SAL_TYPE=ATMEGARF_SAL; BOARD=ATMEGA256RFR2_XPLAINED_PRO; PHY_ATMEGARFR2
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega
    ../../../../../services/common_hw_timer/mega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega/lib
    ../../../../../services/common_hw_timer/mega/lib/: megarfr2_lib_hw_timer.r90
  group thirdparty/wireless/services/sal/atmegarf_sal/src
    ../../../../../services/sal/atmegarf_sal/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal_types.h sal_generic.h sal.h
  group thirdparty/wireless/services/mega/drivers/tc
    ../../../../../services/mega/drivers/tc/: tc_megarf.c tc_megarf.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/megarf
    ../../../../../services/sleep_mgr/megarf/: sleep_mgr.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sysTimer.c sys.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sysConfig.h sysTimer.h sys.h sysEncrypt.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkGroup.c nwkTx.c nwkSecurity.c nwkRx.c nwkRouteDiscovery.c nwkFrame.c nwkRoute.c nwkDataReq.c nwk.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwk.h nwkGroup.h nwkTx.h nwkDataReq.h nwkRoute.h nwkSecurity.h nwkRx.h nwkCommand.h nwkRouteDiscovery.h nwkFrame.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/atmegarfr2/src
    ../../../../source/phy/atmegarfr2/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/atmegarfr2/inc
    ../../../../source/phy/atmegarfr2/inc/: phy.h atmegarfr2.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: main.c wsndemo.c commands.c wsndemo.h commands.h config.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/atmega256rfr2_xplained_pro
    ../: conf_sleepmgr.h conf_clock.h conf_sio2host.h conf_board.h conf_trx_access.h conf_hw_timer.h conf_usart_serial.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/atmega256rfr2_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c led.h atmega256rfr2_xplained_pro.h
  group mega/drivers/macsc
    ../../../../../../../mega/drivers/macsc/: macsc_megarf.c macsc_megarf.h
  group mega/drivers/usart
    ../../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/sleep
    ../../../../../../../mega/drivers/sleep/: sleep_megarf.h sleep.h
  group mega/drivers/cpu
    ../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/utils
    ../../../../../../../mega/utils/: compiler.h progmem.h assembler.h status_codes.h
  group mega/utils/preprocessor
    ../../../../../../../mega/utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group mega/utils/assembler
    ../../../../../../../mega/utils/assembler/: iar.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../../../../common/services/serial/megarf_usart/: usart_serial.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/mega
    ../../../../../../../common/services/sleepmgr/mega/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../../common/services/ioport/mega/: ioport.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../common/boards/: board.h
