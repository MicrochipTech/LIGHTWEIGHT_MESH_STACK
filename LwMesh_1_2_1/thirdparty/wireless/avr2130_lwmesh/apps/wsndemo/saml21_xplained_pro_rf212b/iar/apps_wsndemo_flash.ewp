# IAR project apps_wsndemo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; RTC_COUNT_ASYNC=true; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAML21J18A__; SPI_CALLBACK_MODE=false; SAL_TYPE=AT86RF2xx; PHY_AT86RF212B; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\sam0\drivers\system\reset\reset_sam_l; ..\..\..\..\..\..\..\sam0\drivers\system\clock\clock_saml21; ..\..\..\..\..\services\trx_access; ..\..\..\..\..\services\common_hw_timer; ..\..\..\..\..\..\..\sam0\drivers\system\pinmux; ..\..\..\..\..\..\..\sam0\utils\cmsis\saml21\include; ..\..\..\..\..\..\..\sam0\drivers\tc; ..\..\..\..\..\..\..\sam0\utils\cmsis\saml21\source; ..\..\..\..\..\..\..\common\boards; ..\..\..\..\source\nwk\inc; ..\..\..\..\..\..\..\sam0\drivers\sercom; ..\..\..\..\..\..\..\sam0\drivers\system\power\power_sam_l; ..\..\..\..\..\..\..\sam0\drivers\system\interrupt; ..; ..\..; ..\..\..\..\..\services\sleep_mgr; ..\..\..\..\..\..\..\sam0\utils\header_files; ..\..\..\..\..\..\..\sam0\drivers\sercom\spi; ..\..\..\..\..\..\..\sam0\drivers\rtc; ..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\sam0\drivers\system; ..\..\..\..\..\..\..\sam0\drivers\system\clock; ..\..\..\..\..\..\..\sam0\boards\saml21_xplained_pro; ..\..\..\..\..\..\..\sam0\drivers\tc\tc_sam_l_c; ..\..\..\..\..\..\..\sam0\drivers\port; ..\..\..\..\..\..\..\sam0\drivers\system\reset; ..\..\..\..\..\..\..\sam0\drivers\rtc\rtc_sam_l_c; ..\..\..\..\..\services\sal\inc; ..\..\..\..\..\..\..\common2\services\delay; ..\..\..\..\source\phy\at86rf212b\inc; ..\..\..\..\..\..\..\sam0\utils; ..\..\..\..\source\sys\inc; ..\..\..\..\..\..\..\sam0\boards; ..\..\..\..\..\services\common_hw_timer\sam0; ..\..\..\..\..\..\..\sam0\drivers\system\interrupt\system_interrupt_saml21; ..\..\..\..\..\..\..\sam0\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\sam0\drivers\extint\extint_sam_l_c; ..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\sam0\utils\preprocessor; ..\..\..\..\..\..\..\common2\services\delay\sam0; ..\..\..\..\..\..\..\sam0\drivers\extint; ..\..\..\..\..\..\..\sam0\drivers\sercom\usart; ..\..\..\..\..\..\..\sam0\drivers\system\power; ..\..\..\..\..\addons\sio2host\uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_wsndemo_flash.bin
  ILINK.IlinkOutputFile: apps_wsndemo_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\sam0\utils\linker_scripts\saml21\iar\saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/services/sal/at86rf2xx/src
    ../../../../../services/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/services/sal/inc
    ../../../../../services/sal/inc/: sal.h sal_types.h sal_generic.h
  group thirdparty/wireless/services/sleep_mgr
    ../../../../../services/sleep_mgr/: sleep_mgr.h
  group thirdparty/wireless/services/sleep_mgr/sam0
    ../../../../../services/sleep_mgr/sam0/: sleep_mgr.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/src
    ../../../../source/sys/src/: sysEncrypt.c sysTimer.c sys.c
  group thirdparty/wireless/avr2130_lwmesh/source/sys/inc
    ../../../../source/sys/inc/: sysTimer.h sys.h sysConfig.h sysEncrypt.h
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/src
    ../../../../source/nwk/src/: nwkTx.c nwkGroup.c nwkSecurity.c nwkRx.c nwkRouteDiscovery.c nwkFrame.c nwkRoute.c nwkDataReq.c nwk.c
  group thirdparty/wireless/avr2130_lwmesh/source/nwk/inc
    ../../../../source/nwk/inc/: nwkTx.h nwkSecurity.h nwkFrame.h nwk.h nwkRoute.h nwkDataReq.h nwkRx.h nwkRouteDiscovery.h nwkGroup.h nwkCommand.h
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/src
    ../../../../source/phy/at86rf212b/src/: phy.c
  group thirdparty/wireless/avr2130_lwmesh/source/phy/at86rf212b/inc
    ../../../../source/phy/at86rf212b/inc/: phy.h at86rf212b.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo
    ../../: main.c wsndemo.c commands.c commands.h config.h wsndemo.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/saml21_xplained_pro_rf212b
    ../: conf_hw_timer.h conf_sio2host.h conf_rtc.h conf_spi.h conf_sleepmgr.h conf_clocks.h conf_board.h conf_extint.h conf_trx_access.h
  group thirdparty/wireless/avr2130_lwmesh/apps/wsndemo/saml21_xplained_pro_rf212b/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../../sam0/utils/cmsis/saml21/include/: saml21j18a.h saml21e18a.h saml21g18a.h saml21.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../../sam0/utils/cmsis/saml21/include/component/: rstc_100.h trng.h tc_100.h eic_100.h port.h wdt.h dmac.h evsys.h sercom.h mtb.h pac_100.h supc_100.h tcc_200.h dac.h osc32kctrl.h ac.h adc_100.h ccl.h pm_100.h dsu.h usb.h tal.h opamp.h oscctrl.h gclk_100.h nvmctrl_301.h mclk_100.h rtc_100.h aes.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../../sam0/utils/cmsis/saml21/include/instance/: tcc0_200.h tcc2_200.h rstc_100.h tal.h eic_100.h gclk_100.h tcc1_200.h sercom4.h opamp.h osc32kctrl.h ccl.h sercom2.h tc1_100.h tc2_100.h tc3_100.h tc4_100.h oscctrl.h mclk_100.h aes.h dsu.h sercom0.h adc_100.h evsys.h pm_100.h nvmctrl_301.h sercom5.h sercom3.h wdt.h tc0_100.h supc_100.h dmac.h sercom1.h rtc_100.h pac_100.h usb.h ac.h dac.h mtb.h port.h trng.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../../sam0/utils/cmsis/saml21/include/pio/: saml21j18a.h saml21e18a.h saml21g18a.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: preprocessor.h mrecursion.h mrepeat.h stringz.h tpaste.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/rtc
    ../../../../../../../sam0/drivers/rtc/: rtc_tamper.h rtc_count.h rtc_count_interrupt.h
  group sam0/drivers/rtc/rtc_sam_l_c
    ../../../../../../../sam0/drivers/rtc/rtc_sam_l_c/: rtc_count_interrupt.c rtc_count.c
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart_interrupt.c usart.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../sam0/drivers/system/clock/clock_saml21/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/extint
    ../../../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_l_c
    ../../../../../../../sam0/drivers/extint/extint_sam_l_c/: extint.c
  group sam0/drivers/tc
    ../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_l_c
    ../../../../../../../sam0/drivers/tc/tc_sam_l_c/: tc.c
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../../sam0/boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
